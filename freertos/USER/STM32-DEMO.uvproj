# Keil uVision project STM32-DEMO.uvproj, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c misc: --c99
  c include: ..\CMSIS;..\FWlib\inc;..\FWlib\src;..\USER;..\Source\include;..\Source\portable\Keil\ARM_CM3;..\Source\portable\MemMang;..\Source;..\GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUPCODE
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c
    ../FWlib/src/: system.c usart.c driver.c tim.c RTC.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FreeRTOS
    ../Source/: tasks.c list.c FreeRTOSConfig.h
    ../Source/portable/Keil/ARM_CM3/: port.c
    ../Source/portable/MemMang/: heap_4.c
  group ESP8266
    ../FWlib/src/: sta_tcpclent_test.c esp8266_drive.c esp8266_public.c
  group KEY
    ../FWlib/src/: key.c
  group SYN6288
    ../FWlib/inc/: SYN6288.C
  group ADC
    ../FWlib/src/: ADC.c
  group GUI
    ../GUI/: GUI.c lcd.c test.c led.c

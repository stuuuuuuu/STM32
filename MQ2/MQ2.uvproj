# Keil uVision project MQ2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: MQ2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc;.\src
  group Source Group 1
    ./: STARTUP.A51
    ./src/: led.c main.c ds18b20.c time0.c ADC.C

# Keil uVision project Ultrasonic.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Ultrasonic +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc;.\src;.\src
  group Source Group 1
    ./: STARTUP.A51 main.c
  group 1602
    ./src/: led.c
  group syn6288
    ./src/: usart.c syn6288.c
  group Tim0
    ./src/: time0.c
  group DS18B20
    ./src/: DS18B20.c
  group HC-SR04
    ./src/: HC-SR04.c
